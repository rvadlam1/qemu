## hw/dspic/Kconfig
```kconfig
config DSPICEXP_MCU
    bool

config DSPICEXAMPLE_BOARD
    bool
    select DSPICEXP_MCU
```
